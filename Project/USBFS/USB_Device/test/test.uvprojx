# Keil uVision project test.uvprojx, settings and files
target test (6190000::V6.19::ARMCLANG)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32E10X,GD32E103V_EVAL
  c include: .\;..\..\..\..\Utilities;..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\..\..\Firmware\GD32E10x_usbfs_driver\Include;..\..\..\..\Firmware\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: app.c custom_hid_core.c gd32e10x_it.c usb_delay.c custom_hid_core.h gd32e10x_it.h gd32e10x_libopt.h usb_conf.h usb_delay.h usbd_conf.h delay.c
  group cmsis
    ./: system_gd32e10x.c
  group lib
    ../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_pmu.c gd32e10x_ctc.c
  group startup
    ./: startup_gd32e10x.s
  group usb
    ../../../../Firmware/GD32E10x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
